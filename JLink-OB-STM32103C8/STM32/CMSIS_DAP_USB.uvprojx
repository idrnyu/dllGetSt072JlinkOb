# Keil uVision project CMSIS_DAP_USB.uvprojx, settings and files
target CMSIS-DAP-V1-F102 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS-DAP-V1 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V1 STM32F102CB
  c include: .;.\STM32F10x_StdPeriph_Driver\inc;.\USBStack\inc;.\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CMSIS_DAP-C8.sct
  group CMSIS-DAP
    ./: startup_stm32f10x_md.s system_stm32f10x.c CMSIS-DAP.c UserApp.c usb_config.c usbd_STM32F103.c usbd_user_cdc_acm.c usbd_user_hid.c DAP_config.h
  group Source
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c
  group USBStack
    USBStack/src/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_hid.c
target CMSIS-DAP-V1-F103 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CMSIS-DAP-V1-F103 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V1
  c include: .;.\STM32F10x_StdPeriph_Driver\inc;.\USBStack\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CMSIS_DAP.sct
target CMSIS-DAP-V2 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CMSIS-DAP-V2 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V2
  c include: .;.\STM32F10x_StdPeriph_Driver\inc;.\USBStack\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CMSIS_DAP-C8.sct
target STM32RF (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: CMSIS-DAP-RF +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_STM32RF
  c include: .;.\STM32F10x_StdPeriph_Driver\inc;.\USBStack\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CMSIS_DAP.sct
